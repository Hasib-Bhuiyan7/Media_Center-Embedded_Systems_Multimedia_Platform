# Keil uVision project Blinky.uvprojx, settings and files
target LPC1768 Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress 550
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Core Code
    ./: startup_LPC17xx.s system_LPC17xx.c core_cm3.c
  group Source Code
    ./: Blinky.c IRQ.c GLCD_SPI_LPC1700.c LED.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c adcuser.c KBD.c snake.c gallery.c blockDodger.c
  group Pictures
    ./: soundWaitScreen.c soccerball.c car.c basketball.c bird.c
